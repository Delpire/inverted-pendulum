# IAR project eeva.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx
  ICCARM.CCIncludePath2: user_code; ..\..\libraries\misc\inc; ..\..\hardware_config; ..\..\st_stdperiph_lib\CMSIS\Include; ..\..\st_stdperiph_lib\CMSIS\Device\ST\STM32F4xx\Include; ..\..\st_stdperiph_lib\STM32F4xx_StdPeriph_Driver\inc; ..\..\glo\glo_objects\inc; ..\..\glo\glo_link\inc; ..\..\glo\glo_os\inc; ..\..\glo_tasks\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: eeva.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: ..\..\hardware_config\stm32401xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  group glo/glo_link
    ../../glo/glo_link/: glo_rx_link.cpp glo_tx_link.cpp
  group glo/glo_link/inc
    ../../glo/glo_link/inc/: glo_rx_link.h glo_tx_link.h
  group glo/glo_objects
    ../../glo/glo_objects/: glo_objects.cpp glo_write_callbacks.cpp
  group glo/glo_objects/inc
    ../../glo/glo_objects/inc/: glo_object_template.h glo_objects.h glo_types.h glo_write_callbacks.h
  group glo/glo_os
    ../../glo/glo_os/: config_glo_os.cpp glo_object_queue.cpp glo_os.cpp stm32f4xx_interrupts.cpp
  group glo/glo_os/inc
    ../../glo/glo_os/inc/: glo_object_queue.h glo_os.h glo_os_mutex.h glo_os_references.h glo_os_sys.h
  group glo_tasks/inc
    ../../glo_tasks/inc/: communications_task.h complementary_filter_task.h hf_control_task.h leds_task.h main_control_task.h telemetry_send_task.h
  group hardware_config
    ../../hardware_config/: stm32f4xx_conf.h system_stm32f4xx_eeva_board.c
  group libraries/misc
    ../../libraries/misc/: analog_in.cpp complementary_filter.cpp coordinate_conversions.cpp debug_printf.cpp derivative_filter.cpp digital_in.cpp digital_out.cpp dma_rx.cpp dma_tx.cpp encoder.cpp flash_storage.cpp green_leds.cpp mpu6000.cpp pid_controller.cpp pwm_out.cpp six_point_sensor_cal.cpp tb6612fng.cpp usart.cpp usec_timer.cpp user_leds.cpp user_pb.cpp util_assert.cpp
  group libraries/misc/inc
    ../../libraries/misc/inc/: analog_in.h complementary_filter.h coordinate_conversions.h debug_printf.h derivative_filter.h digital_out.h dma_rx.h dma_tx.h encoder.h flash_storage.h green_leds.h mpu6000.h physical_constants.h pid_controller.h pwm_out.h six_point_sensor_cal.h tb6612fng.h telemetry_text_size.h usart.h usec_timer.h user_leds.h user_pb.h util_assert.h
  group st_stdperiph_lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar
    ../../st_stdperiph_lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s
  group st_stdperiph_lib/STM32F4xx_StdPeriph_Driver/src
    ../../st_stdperiph_lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group user_code
    user_code/: main.cpp
